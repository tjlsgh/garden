# Keil uVision project Garden_LiteOS.uvprojx, settings and files
target Garden_LiteOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Garden_LiteOS +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\Include;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\LiteOS\arch\arm\arm-m\cortex-m3;..\..\LiteOS\arch\arm\arm-m\include;..\..\LiteOS\cmsis\1.0;..\..\LiteOS\cmsis\2.0;..\..\LiteOS\cmsis;..\..\LiteOS\kernel\include;..\..\LiteOS\kernel\base\include;..\..\LiteOS\kernel\extended\include;..\..\LiteOS\OS_CONFIG;..\..\User\Key;..\..\User\usart;..\..\User\Common;..\..\User\dht11;..\..\User\ESP8266;..\..\User\wifi;..\..\MQTTPacket\src;..\..\MQTTPacket;..\..\User\mqtt;..\..\User\dht11;..\..\User\delay;..\..\User\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/Key/: bsp_key.c
    ../../User/usart/: bsp_usart.c
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/Common/: Common.c
    ../../User/wifi/: wifi.c
    ../../User/mqtt/: mqtt.c
    ../../User/delay/: delay.c
    ../../User/adc/: bsp_adc.c
  group LiteOS/cmsis
    ../../LiteOS/cmsis/: cmsis_liteos.c
  group LiteOS/kernel
    ../../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memcheck.c los_membox.c los_memory.c
    ../../LiteOS/kernel/base/misc/: los_misc.c
    ../../LiteOS/kernel/base/om/: los_err.c
    ../../LiteOS/kernel/: los_init.c
    ../../LiteOS/kernel/base/mem/common/: los_memstat.c los_memstat.inc los_slab.c los_slabmem.c
  group LiteOS/arch
    ../../LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/config
    ../../LiteOS/OS_CONFIG/: target_config.h
  group Mqtt
    ../../MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../MQTTPacket/: transport.c mqtt_transport.c
